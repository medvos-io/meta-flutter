require dart-sdk.inc

SRCREV = "f16b62ea92cc0f04cfd9166992f93419e425c809"

SRC_URI += "\
    file://0001-External-Toolchain.patch \
"
